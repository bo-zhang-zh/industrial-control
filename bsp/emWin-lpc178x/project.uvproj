# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC17xx (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtthread-lpc +hex
  c flags: Optim=1
  c include: .;..\..\components\finsh;..\..\components\dfs\filesystems\uffs\src\inc;..\..\components\dfs\include;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\uffs;..\..\components\drivers\include;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;CMSIS\CM3\CoreSupport;CMSIS\CM3\DeviceSupport\NXP\LPC177x_8x;applications;drivers;Libraries\include;emWin\Config;emWin\GUI;emWin\Inc;emWin\Application;Usbhost;..\..\components\net\lwip\src;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\..\components\net\lwip\src\include\lwip;..\..\components\CanFestival\include;.\CAN-drv
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\rtthread-lpc178x.sct
  link misc: --keep __fsym_* --keep __vsym_*
--diag_suppress=6329 --diag_suppress=6314
  group Applications
    applications/: application.c startup.c
    ../../examples/file/: listdir.c
  group CMSIS
    CMSIS/CM3/CoreSupport/: core_cm3.c
    CMSIS/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    CMSIS/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group Drivers
    drivers/: board.c sdram.c uart.c
    ./drivers/: GLCD.c AsciiLib.c Cursor.c TouchPanel.c udisk.c fs_mci.c k9f1g08_mtd.c emc_nand.c emac.c uart_int.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Libraries
    ./Libraries/source/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_dac.c lpc177x_8x_eeprom.c lpc177x_8x_emac.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_mci.c lpc177x_8x_mcpwm.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_qei.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c lpc177x_8x_bod.c lpc177x_8x_iap.c lpc177x_8x_lcd.c lpc177x_8x_usbhost.c
  group GUI-emWin
    ./emWin/GUI/: BUTTON.h CHECKBOX.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h EDIT.h emWin_516_Keil4_M3_LE.lib FRAMEWIN.h Global.h GRAPH.h GUI.h GUI_ARRAY.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_HOOK.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_Generic.h GUIDRV_IST3088.h GUIDRV_Lin.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D15G00.h GUIDRV_S1D13748.h GUIDRV_SLin.h GUIDRV_SPage.h GUIDRV_SSD1926.h GUIDRV_Template.h GUIDRV_TemplateI.h HEADER.h ICONVIEW.h IMAGE.h LCD.h LCD_ConfDefaults.h LCD_Protected.h LISTBOX.h LISTVIEW.h LISTWHEEL.h MENU.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h PROGBAR.h RADIO.h SCROLLBAR.h SLIDER.h SPINBOX.h TEXT.h TREEVIEW.h WIDGET.h WM.h WM_GUI.h WM_Intern.h
  group emWin-Config
    ./emWin/Config/: Global.h GUIConf.c GUIConf.h LCDConf.c LCDConf.h SysConf.h GUI_X_RT-thread.c
  group emWin-Inc
    ./emWin/Inc/: BSP.h JLINKDCC.h JLINKMEM.h SEGGER.h TaskPrio.h
  group emWin-Demo
    ./emWin/Application/: GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c IMAGE_SeggerLogo_300x150_565c.c SEGGERDEMO.c GUIDEMO.h GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO.c
  group Filesystem
    ../../components/dfs/filesystems/elmfat/option/: cc936.c ccsbcs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group LwIP
    ../../components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/src/arch/: sys_arch.c
    ../../components/net/lwip/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/src/netif/: etharp.c ethernetif.c slipif.c
  group emWin-App
    ./emWin/Samples/Application/: TOUCH_Sample.c HouseControl.c WindowDLG.c logsig.c RecognitionDLG.c weight.c Reversi.c
    ./emWin/Simulation/: SlaveGUITest.c
    ./emWin/App/: Control.c ControlCB.c PattenView.c PattenViewCB.c SelectFile.c SelectFileCB.c Setting.c SettingCB.c Testing.c TestingCB.c PattenProc.c
  group Usb-host
    ./Usbhost/: usbhost_ms.c
  group FS-uffs
    ../../components/dfs/filesystems/uffs/: dfs_uffs.c uffs_nandif.c uffs_rtthread.c
    ../../components/dfs/filesystems/uffs/src/uffs/: uffs_ecc.c uffs_fd.c uffs_find.c uffs_flash.c uffs_fs.c uffs_init.c uffs_mem.c uffs_mtb.c uffs_pool.c uffs_public.c uffs_tree.c uffs_utils.c uffs_version.c uffs_badblock.c uffs_blockinfo.c uffs_buf.c uffs_crc.c uffs_debug.c uffs_device.c
    ../../components/dfs/filesystems/uffs/src/utils/: mkuffs.c
    ../../components/drivers/mtd/: mtd_nand.c
  group CanFestival
    ../../components/CanFestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c symbols.c sync.c can_timer.c
  group CAN-Slave
    ./CAN-drv/: Slave_board.c TestSlave.c Slave.c LPC178x_can_timer.c
  group Lwip-Demo
    ./lwip-demo/: telnet.c tcpserver.c
